# Keil uVision project PWM_DT.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: PWM_DT +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source
    ../: PWM_Deadtime.C
  group Library
    ../../../../Library/StdDriver/src/: sys.c uart.c adc_6.c condition_4.c mppt_track_5.c pwm_6.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
